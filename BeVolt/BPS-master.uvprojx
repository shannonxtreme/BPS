# Keil uVision project BPS-master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413RHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00180000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BPS-master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER __FPU_PRESENT
  c include: ..\;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS;.\CMSIS\Include;.\App;.\App\inc;.\App\src;.\Drivers;.\Drivers\inc;.\Drivers\src;.\Periphs;.\Periphs\inc;.\Periphs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group App/src
    ./App/src/: main.c Current.c Voltage.c Temperature.c Contactor.c SoC.c
  group App/inc
    ./App/inc/: config.h common.h Current.h Temperature.h Voltage.h Contactor.h SoC.h
  group Drivers/src
    ./Drivers/src/: EEPROM.c LTC681x.c LTC6811.c LED.c BatteryBalancing.c
  group Drivers/inc
    ./Drivers/inc/: EEPROM.h LTC681x.h LTC6811.h LED.h BatteryBalancing.h
  group Periphs/src
    ./Periphs/src/: ADC.c CAN.c I2C.c SPI.c UART.c WDTimer.c SysTick.c fifo.c PLL.c
  group Periphs/inc
    ./Periphs/inc/: ADC.h CAN.h FIFO.h I2C.h SPI.h UART.h WDTimer.h SysTick.h PLL.h
  group StdPeriphLibrary
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_dma.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
